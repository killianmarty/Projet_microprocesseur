# Keil uVision project quickstart.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: quickstart
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PRE_INCLUDE_GLOBAL_H
  c include: ..\projet
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: init_Comm.c main.c utilities.h utilities.c screen.c screen.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
